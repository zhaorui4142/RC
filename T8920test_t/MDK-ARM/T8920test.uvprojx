# Keil uVision project T8920test.uvprojx, settings and files
target T8920test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: T8920test
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../Drivers/LT8920;../Drivers/PS2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_dma.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/LT8920
    ../Drivers/LT8920/: LT8920_IO.c LT8920_master.c LT8920_slave.c
  group Drivers/PS2
    ../Drivers/PS2/: pstwo.c
  group Application/User
    ../Src/: stm32f0xx_it.c main.c stm32f0xx_hal_msp.c gpio.c usart.c spi.c tim.c crc.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
software components: CMSIS:CORE 4.1.0
